# Keil uVision project STM32Template_F103C8T6.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32Template_F103C8T6 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\User;..\Firmware\STM32F10x_StdPeriph_Driver\inc;..\Drivers\Usart;..\Hardware\Led;..\Hardware\oled;..\Drivers\I2C;..\Hardware\MAX30102
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: main.c stm32f10x_it.c system_stm32f10x.c Systick.c Systick.h
  group Fimware
    ../Firmware/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_i2c.c
    ../../00_Template_F103C8T6/Firmware/STM32F10x_StdPeriph_Driver/src/: stm32f10x_usart.c
  group CMSIS
    ../Firmware/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Hardware
    ../Hardware/Led/: Led.c Led.h
    ../Hardware/MAX30102/: MAX30102.c MAX30102.h
  group Drivers
    ../Drivers/Usart/: Usart1.c
    ../Drivers/I2C/: I2C.c I2C.h
software components: CMSIS:CORE 5.2.0
